# Keil uVision project FreeRTOS.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\User\Lib\Inc;..\User\FreeRTOS\include;..\User\FreeRTOS\portable\GCC\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ../User/: main.c
    ../User/Lib/Src/: adc.c led.c uart.c DS18B20.c tim2.c pwm.c
  group FreeRTOS
    ../User/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../User/FreeRTOS/portable/MemMang/: heap_4.c
    ../User/FreeRTOS/portable/GCC/ARM_CM3/: port.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
